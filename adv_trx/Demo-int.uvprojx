# Keil uVision project Demo-int.uvprojx, settings and files
target MS1656Adv-int (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Demo-int +hex
  AfterMake: fromelf --vhx --32x1 -o .\Objects\Demo.bin .\Objects\Demo.axf
  c flags: Optim=1 wLevel=2
  c define: WMODE_INT BLE_SPIDEBUGx
  c include: .\USER\inc;.\Communication\inc;..\FWLB\inc;..\DEVICE
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group DEVICE
    ../DEVICE/: system_cx32l003.c startup_cx32l003.s
  group FWLB
    ../FWLB/src/: cx32l003_adc.c cx32l003_advtim.c cx32l003_awk.c cx32l003_beeper.c cx32l003_clktrim.c cx32l003_crc.c cx32l003_debug.c cx32l003_exti.c cx32l003_gpio.c cx32l003_i2c.c cx32l003_iwdt.c cx32l003_lptimer.c cx32l003_lpuart.c cx32l003_lvd.c cx32l003_owire.c cx32l003_pca.c cx32l003_rcc.c cx32l003_rtc.c cx32l003_spi.c cx32l003_syscon.c cx32l003_timer.c cx32l003_uart.c cx32l003_vc.c cx32l003_wwdt.c misc.c
  group USER
    ./USER/src/: BSP.c Spi.c MG127.c MG127-test.c MG127-int.c key.c main-int.c
software components: CMSIS:CORE 4.1.0
